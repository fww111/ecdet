# Keil uVision project demo.uvprojx, settings and files
target demo_rtos_cm4 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x8000000,0x100000)
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ../include;../src;../../CMSIS/Include
